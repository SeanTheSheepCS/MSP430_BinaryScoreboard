# IAR project blink-efwd.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlib\dl430fn.h
  General.OGChipSelectMenu: MSP430F2122 MSP430F2122
  General.GStackSize2: 120
  General.GHeapSize2: 40
  General.RadioHeapSizeType: 0
  ICC430.CCOptLevel: 0
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: ..\lnk430F2122_BLINK.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.RTConfigPath: xxx.h
  ICC430.CCDefines: NDEBUG
  ICC430.CCOptLevel: 3
  ICC430.ADefines: NDEBUG
  XLINK.XclFile: lnk0t.xcl
  group (top)
    ../: binary_counter-efwd-01.c binary_counter-efwd-01.h buttons.c buttons.h cstartup.s43 input_pins.c input_pins.h io430x21x2.h leds.c leds.h main.c main.h msp430x21x2.h rgb_leds.c rgb_leds.h typedef_MSP430.h
